Properties of the parts of a building model (IFC4)

# File
Description: Universal-Temperaturregler, 0–100 °C, Hysterese 0,5–5 K, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: D4770026, Universal-Temperaturregler, 0–100 °C, Hysterese 0,5–5 K, Inneneinstellung
In: Raum
Description: Elektronischer Universal-Temperaturregler. Durch verschiedene Fühlerausführungen ist ein universeller Einsatz in der Heizungs-, Lüftungs-, Klima- und Kältetechnik sowie im Maschinen und Apparatebau möglich. Der Heizzustand wird durch eine rote LED angezeigt. Fühler gehören nicht zum Lieferumfang. Die Fühlerleitung ist bis zu 100 m verlängerbar bei Verwendung eines Kabelquerschnitts von min. 1,5 mm². Universal-Temperaturregler, 0–100 °C, Hysterese 0,5–5 K, Inneneinstellung; Classification: EC002616 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: D4770026; ModelLabel: ETR 77.009-5; GlobalTradeItemNumber: 4050528023810; ProductURL: https://alre.de/produkt_D4770026
Pset_Specification - NominalLength: 0.169 m; NominalWidth: 0.096 m; NominalDepth: 0.056 m; NetWeight: 0.41
Pset_ALRE_ETIM_Properties - Max. Betriebstemperatur: 50; Ausführung des Sensors: PTC; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Elektronische Ausführung: yes; Anzahl der Kontakte als Wechsler: 1; ETIM-Klasse: EC002616; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-D4770026.pdf
